# Keil uVision project ISP_UART0_1wire.uvproj, settings and files
target GPIO (MCS-51)
  device: MS51FB9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: MS51_UART0_ISP +hex
  AfterMake: ..\..\..\..\Library\Startup\exe\hex2bin.exe  .\output\@L.hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\..\..\..\Library\Device\Include;..\..\..\..\Library\StdDriver\inc;
  group Source Group 1
    ../: main.c
  group Common
    ../: isp_uart0_1wire_p07.c
  group Startup
    ../../../../Library/Startup/Keil/: STARTUP.A51
